require recipes-core/images/picocom-development.inc

IMAGE_FSTYPES = "ext4"
