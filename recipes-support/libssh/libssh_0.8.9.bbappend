PACKAGECONFIG:remove = "gcrypt"
