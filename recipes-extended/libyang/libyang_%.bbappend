# ptest is disabled as it depends on valgrind which is not yet available for riscv machines
PTEST_ENABLED = "0"

COMPATIBLE_HOST:riscv32 = "riscv32"
