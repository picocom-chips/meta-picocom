RDEPENDS:${PN}-ptest:remove:riscv32 = "strace"
