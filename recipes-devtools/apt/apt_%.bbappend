FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-include-stdint.h-for-missing-defination-of-uint16_t.patch"

